# Keil uVision project EX.uvprojx, settings and files
target CODE (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EX +hex
  AfterMake: E:\WORK\Project_List\MULTI_ROTOR_TYPE_AIRCRAFT\GFLY\FLY\commit.bat
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\GLIB\SYSTEM;..\GLIB\HARDWARE;..\GLIB\STM32F10x_StdPeriph_Driver\inc;.\USER;..\GLIB\CMSIS\CM3\CoreSupport;.\USER\APP;..\GLIB\PERIPHERAL\LCD\lcd12864;..\GLIB\PERIPHERAL\DHT11;..\GLIB\PERIPHERAL\SD;..\GLIB\FATFS\src;..\GLIB\FATFS\exfuns;..\GLIB\PERIPHERAL\LCD;..\GLIB\PERIPHERAL\DS18B20;.\USER\CONFIG;..\GLIB\PERIPHERAL\ULTRASONIC;..\GLIB\PERIPHERAL\HMC5883L;..\GLIB\PERIPHERAL\MPU6050;.\USER\APP\Kalman_Fliter
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../GLIB/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../GLIB/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./: README.md
  group FWLIB
    ../GLIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: system_stm32f10x.c stm32_config.h main.cpp stm32f10x_it.cpp
  group TASK
    ./USER/TASK/: task_bmp085.cpp loop_fast.cpp task_6050.cpp task_cap_rc.cpp task_hmc5883l.cpp task_led.cpp task_pwm_ex.cpp task_ultrasonic.cpp task_gps.cpp task_display.cpp UI.cpp UI_User.cpp task_stepmotor.cpp
  group SYSTEM
    ../GLIB/SYSTEM/: sys.c usart.c minos_delay.c sys_usart.c usr_usart.c sys_os.c
  group HARDWARE
    ../GLIB/HARDWARE/: G32_I2c.c G32_Timer.c G32_Timer_Cap.c gpio.c pwm.c spi.c stmflash.c bkp.c G32_HI2c.c
  group APP
    ./USER/APP/Kalman_Fliter/: kalman.c
    ../GLIB/ALGORITHM/: binary_chop.c
    ./USER/APP/: galileo_0920.c
  group PERIPHERAL
    ../GLIB/PERIPHERAL/MPU6050/: MPU6050.c
    ../GLIB/PERIPHERAL/NRF24L01/: G32_Nrf24l01.C
    ../GLIB/PERIPHERAL/ULTRASONIC/: ultrasonic.c
    ../GLIB/PERIPHERAL/HMC5883L/: hmc5883l.c
    ../GLIB/PERIPHERAL/BMP085/: bmp085.c
    ../GLIB/PERIPHERAL/GPS/: GPS_DRIVER.c
  group COMMUNICATION
    ./USER/APP/: rc.c data_transfer.c
  group ALGORITHM
    ./USER/APP/: IMU.c filter.c Control.c motor.c Balance.cpp pfilter.c
  group DATA
    ./USER/APP/: bak.c
  group DISPLAY
    ../GLIB/PERIPHERAL/LCD/: LCD.c ILI93.c touch.c
    ./USER/TASK/: font_User.c
